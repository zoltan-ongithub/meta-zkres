
FEATURE_PACKAGES_switch = "packagegroup-zkres-switch"
FEATURE_PACKAGES_gateway = "packagegroup-zkres-gateway"

inherit core-image
